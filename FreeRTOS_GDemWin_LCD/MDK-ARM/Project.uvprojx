# Keil uVision project Project.uvprojx, settings and files
target FreeRTOS_GDemWin_LCD (6160000::V6.16::ARMCLANG)
  device: GD32H759IM GigaDevice
  pack: GigaDevice.GD32H7xx_DFP.1.4.0
  cpu: IRAM(0x24000000,0x000E0000) IRAM2(0x00000000,0x00010000) IROM(0x08000000,0x03C0000) XRAM(0x20000000,0x00010000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_GDEMWIN
  c misc: -Wno-invalid-source-encoding
  c include: ..\User;..\User\systick;..\User\lcd;..\User\sdram;..\User\usart;..\User\led;..\User\gui;..\User\touch;..\GD32H7xx_GDemWin652\Include;..\FreeRTOS\include;..\FreeRTOS;..\FreeRTOS\portable\GCC\ARM_CM7\r0p1;..\FreeRTOS\portable\MemMang;..\Firmware\CMSIS\GD\GD32H7xx\Include;..\Firmware\GD32H7xx_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3c0000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  group Startup
    ../Firmware/CMSIS/GD/GD32H7xx/Source/ARM/: startup_gd32h7xx.s
  group CMSIS
    ../Firmware/CMSIS/GD/GD32H7xx/Source/: system_gd32h7xx.c
  group Periphal
    ../Firmware/GD32H7xx_standard_peripheral/Source/: gd32h7xx_adc.c gd32h7xx_can.c gd32h7xx_cau.c gd32h7xx_cau_aes.c gd32h7xx_cau_des.c gd32h7xx_cau_tdes.c gd32h7xx_cmp.c gd32h7xx_cpdm.c gd32h7xx_crc.c gd32h7xx_ctc.c gd32h7xx_dac.c gd32h7xx_dbg.c gd32h7xx_dci.c gd32h7xx_dma.c gd32h7xx_edout.c gd32h7xx_efuse.c gd32h7xx_enet.c gd32h7xx_exmc.c gd32h7xx_exti.c gd32h7xx_fac.c gd32h7xx_fmc.c gd32h7xx_fwdgt.c gd32h7xx_gpio.c gd32h7xx_hau.c gd32h7xx_hau_sha_md5.c gd32h7xx_hpdf.c gd32h7xx_hwsem.c gd32h7xx_i2c.c gd32h7xx_ipa.c gd32h7xx_lpdts.c gd32h7xx_mdio.c gd32h7xx_mdma.c gd32h7xx_misc.c gd32h7xx_ospi.c gd32h7xx_ospim.c gd32h7xx_pmu.c gd32h7xx_rameccmu.c gd32h7xx_rcu.c gd32h7xx_rspdif.c gd32h7xx_rtc.c gd32h7xx_rtdec.c gd32h7xx_sai.c gd32h7xx_sdio.c gd32h7xx_spi.c gd32h7xx_syscfg.c gd32h7xx_timer.c gd32h7xx_tli.c gd32h7xx_tmu.c gd32h7xx_trigsel.c gd32h7xx_trng.c gd32h7xx_usart.c gd32h7xx_vref.c gd32h7xx_wwdgt.c
  group App
    ../User/: main.c gd32h7xx_it.c
  group GUI
    ../User/gui/: LCDConf.c GUI_X_FreeRTOS.c GUIConf.c
    ../GD32H7xx_GDemWin652/Lib/: GDemWin_CM7_OS_DP.lib
  group BSP
    ../User/lcd/: bsp_lcd.c
    ../User/sdram/: bsp_exmc_sdram.c
    ../User/usart/: bsp_usart.c
    ../User/led/: bsp_gpio_led.c
    ../User/systick/: systick.c
    ../User/dwt/: bsp_dwt_delay.c
    ../User/touch/: bsp_i2c.c bsp_gt1151qm.c touch_task.c
  group FreeRTOSCore
    ../FreeRTOS/: tasks.c queue.c list.c timers.c event_groups.c stream_buffer.c
  group FreeRTOSPort
    ../FreeRTOS/portable/GCC/ARM_CM7/r0p1/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group AppWizardSource
    ../../AppWizard/Source/CustomCode/: Application.c ID_SCREEN_00_Slots.c
    ../../AppWizard/Source/Generated/: Resource.c ID_SCREEN_00.c APPWConf.c
    ../../AppWizard/Source/: APPW_MainTask.c
  group AppWizardResource
    ../../AppWizard/Resource/Font/: NettoOT_40_Normal_EXT_AA4.c
    ../../AppWizard/Resource/Text/: APPW_Language_0.c
